# IAR project embox.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: __IAR__; CLI_CMD_STM8S; CLI; SWUART
  ICCSTM8.CCIncludePath2: inc
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: D:\Project\X1\inc
  OBJCOPY.OOCOutputFile: emb20.hex
  ILINK.IlinkOutputFile: embox.out
  ILINK.IlinkIcfFile: D:\Project\X1\settings\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    src/: main.c
  group app/config
    settings/: lnkstm8s003f3.icf
  group app/src
    src/: board.c cli.c cli_list.c clock.c cmd.c ds18b20.c hlw8012.c hlw8012_data.c light.c serial.c swuart.c
